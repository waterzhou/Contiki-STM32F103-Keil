# Keil uVision project ContikiDemo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ContikiDemo
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\libraries\CMSIS;..\libraries\STM32F10x_StdPeriph_Driver\inc;..\user;..\user\led;..\contiki\cpu\stm32f103;..\contiki\core;..\contiki\core\sys;..\contiki\core\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group cmsis
    ../libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group fwlib
    ../libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../user/: stm32f10x_it.c contiki-main.c
    ../user/led/: bsp_led.c
  group doc
    ../doc/: ReadMe.txt
  group cpu
    ../contiki/cpu/stm32f103/: clock.c debug-uart.c
  group core
    ../contiki/core/sys/: autostart.c etimer.c process.c timer.c
